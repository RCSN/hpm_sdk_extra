# IAR project hpmicro_cangaroo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM5361xCBx HPMicro HPM5361xCBx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEO=y; HPMSOC_HAS_HPMSDK_MMC=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_DAC=y; HPMSOC_HAS_HPMSDK_OPAMP=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y; USE_DMA_MGR=1; WS2812_USE_SPI=1; CONFIG_SLCAN0; CONFIG_SLCAN1; CONFIG_SLCAN2; CONFIG_SLCAN3
  ICCRISCV.CCIncludePath2: ../../../../../../sdk_env_v1.8.0/hpm_sdk/arch; ../../../../../MicroLinkPro/microlinkpro_hpm5321/hpm5300evk; ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/HPM5361; ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/ip; ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/HPM5361/toolchains; ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/HPM5361/boot; ../../../../../../sdk_env_v1.8.0/hpm_sdk/drivers/inc; ../../../../../../sdk_env_v1.8.0/hpm_sdk/utils; ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/debug_console; ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/usb/device; ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/spi; ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/dma_mgr; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/common; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/osal; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/core; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/cdc; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/hid; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/midi; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/msc; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/audio; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/video; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/hub; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/wireless; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/port/ehci; ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryrb; ../build_tmp/generated/include; ../../inc; ../../protocol/slcan/inc; ../../ws2812; ../../protocol; ../../protocol/driver/mcan
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=1M
  ILINK.IlinkIcfFile: ..\..\..\..\..\MicroLinkPro\microlinkpro_hpm5321\microlinkpro_app\linkers\segger\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEO=y; HPMSOC_HAS_HPMSDK_MMC=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_DAC=y; HPMSOC_HAS_HPMSDK_OPAMP=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y; USE_DMA_MGR=1; WS2812_USE_SPI=1; CONFIG_SLCAN0; CONFIG_SLCAN1; CONFIG_SLCAN2; CONFIG_SLCAN3; NDEBUG
  group application/protocol
    E:/software/HPM5300/MicroLinkPro/hpm_sdk_extra/demos/cangaroo_hpmicro/protocol/: usb2can.c
  group application/protocol/driver/mcan
    E:/software/HPM5300/MicroLinkPro/hpm_sdk_extra/demos/cangaroo_hpmicro/protocol/driver/mcan/: mcan.c
  group application/protocol/slcan/src
    E:/software/HPM5300/MicroLinkPro/hpm_sdk_extra/demos/cangaroo_hpmicro/protocol/slcan/src/: slcan.c
  group application/src
    E:/software/HPM5300/MicroLinkPro/hpm_sdk_extra/demos/cangaroo_hpmicro/src/: main.c cdc_acm.c
  group application/ws2812
    E:/software/HPM5300/MicroLinkPro/hpm_sdk_extra/demos/cangaroo_hpmicro/ws2812/: WS2812.c
  group soc/HPM5300/HPM5361
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/HPM5361/: system.c hpm_sysctl_drv.c hpm_l1c_drv.c hpm_clock_drv.c hpm_otp_drv.c
  group soc/HPM5300/HPM5361/toolchains
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/HPM5361/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM5300/HPM5361/toolchains/iar
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/HPM5361/toolchains/iar/: startup.s
  group soc/HPM5300/HPM5361/boot
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/soc/HPM5300/HPM5361/boot/: hpm_bootheader.c
  group boards/hpm5300evk
    E:/software/HPM5300/MicroLinkPro/MicroLinkPro/microlinkpro_hpm5321/hpm5300evk/: pinmux.c board.c
  group drivers/src
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/drivers/src/: hpm_uart_drv.c hpm_sdp_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_rng_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pwm_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_acmp_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_tsns_drv.c hpm_dac_drv.c hpm_crc_drv.c hpm_mcan_drv.c hpm_qeiv2_drv.c hpm_enc_pos_drv.c hpm_sei_drv.c hpm_qeo_drv.c hpm_rdc_drv.c hpm_mmc_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c hpm_plb_drv.c hpm_opamp_drv.c
  group utils
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/debug_console/: hpm_debug_console.c
  group components/usb/device
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/usb/device/: hpm_usb_device.c
  group components/spi
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/spi/: hpm_spi.c
  group components/dma_mgr
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/components/dma_mgr/: hpm_dma_mgr.c
  group middleware/cherryusb/core
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/core/: usbd_core.c
  group middleware/cherryusb/port/hpm
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/port/hpm/: usb_dc_hpm.c
  group middleware/cherryusb/class/cdc
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryusb/class/cdc/: usbd_cdc_acm.c
  group middleware/cherryrb
    ../../../../../../sdk_env_v1.8.0/hpm_sdk/middleware/cherryrb/: chry_ringbuffer.c
